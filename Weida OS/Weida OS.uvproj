# Keil uVision project Weida OS.uvproj, settings and files
target Real Time System (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: WeidaOS +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe  --bin -o ./bin/WeidaOS.bin ./Obj/WeidaOS.axf
  c flags: Optim=1
  c define: Scatter_File
  c misc: --exceptions
  c include: .\Source\Mini2440\Include;.\Source\Include;.\Source\Mini2440\Task\Include;.\Source\Games
  memory RVCT9: RAM 0x40000000 size 0x2000
  scatter file: .\Source\Weida OS.sct
  group Weida OS
    ./Source/Kernel/: LoadOS.cpp WeidaOs.cpp Critical_Res.cpp Board.cpp Virtual_Uart.cpp Virtual_LCD.cpp Virtual_RTC.cpp Virtual_TouchScreen.cpp Virtual_Task.cpp Virtual_Memory.cpp New.cpp Math.cpp CreateUserTask.cpp
    ./: ReadMe.txt
  group Mini2440
    ./Source/Mini2440/: startup.s Mini2440.cpp Startup_C.cpp Uart.cpp LCD.cpp RTC.cpp TouchScreen.cpp Task.cpp Memory.cpp IIS.cpp Key_Interup.cpp
    ./Source/Mini2440/MMU/: 2440slib.s mmu.c
  group MusicData
    ./Source/MusicData/: WindowsXP_Wav.cpp
  group Games
    ./Source/Games/: Snake.cpp
